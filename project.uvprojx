# Keil uVision project project.uvprojx, settings and files
target ccr-2022 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F303CC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.0.0
  cpu: IRAM(0x20000000,0x0C000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output ccr_new_v1.6.bin
  c flags: Optim=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1
  c define: GD32F30X_HD, USE_STDPERIPH_DRIVER, __RTTHREAD__, RT_USING_ARM_LIBC, __CLK_TCK=RT_TICK_PER_SECOND
  c include: applications;.;packages\at24cxx-latest;rt-thread\components\libc\compilers\common;rt-thread\components\libc\compilers\common\extension;rt-thread\libcpu\arm\common;rt-thread\libcpu\arm\cortex-m4;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;board;libraries\gd32_drivers;rt-thread\components\finsh;packages\freemodbus-latest\modbus\include;packages\freemodbus-latest\modbus\rtu;packages\freemodbus-latest\modbus\ascii;packages\freemodbus-latest\modbus\tcp;packages\freemodbus-latest\port;.;rt-thread\include;libraries\GD32F30x_Firmware_Library\CMSIS\GD\GD32F30x\Include;libraries\GD32F30x_Firmware_Library\CMSIS;libraries\GD32F30x_Firmware_Library\GD32F30x_standard_peripheral\Include;rt-thread\components\libc\posix\io\poll;rt-thread\components\libc\posix\io\stdio;rt-thread\components\libc\posix\ipc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Applications
    applications/: pid.c i2c_app.c cross_zero_check.c main.c database.c adc_sample.c scr.c
    ./applications/: pid_app.h alarm.c pid_app.c alarm.h adc_sample.h di_check.c
  group at24cxx
    packages/at24cxx-latest/: at24cxx.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscalls.c syscall_mem.c
    rt-thread/components/libc/compilers/common/: time.c stdlib.c
  group CPU
    rt-thread/libcpu/arm/common/: div0.c backtrace.c showmem.c
    rt-thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/hwtimer/: hwtimer.c
    rt-thread/components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    rt-thread/components/drivers/ipc/: workqueue.c ringbuffer.c pipe.c completion.c waitqueue.c ringblk_buf.c dataqueue.c
    rt-thread/components/drivers/misc/: adc.c pin.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/watchdog/: watchdog.c
  group Drivers
    board/: board.c
    libraries/GD32F30x_Firmware_Library/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_hd.s
    libraries/gd32_drivers/: drv_gpio.c drv_soft_i2c.c drv_wdt.c drv_adc.c drv_usart.c drv_hwtimer.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c cmd.c
  group FreeModbus
    packages/freemodbus-latest/samples/: sample_mb_slave.c
    packages/freemodbus-latest/port/: porttcp.c port.c porttimer.c portevent.c portserial.c user_mb_app.c
    packages/freemodbus-latest/modbus/: mb.c
    packages/freemodbus-latest/modbus/functions/: mbfuncinput.c mbfuncother.c mbfuncholding.c mbutils.c mbfunccoils.c mbfuncdiag.c mbfuncdisc.c
    packages/freemodbus-latest/modbus/rtu/: mbcrc.c mbrtu.c
  group Kernel
    rt-thread/src/: timer.c kservice.c ipc.c scheduler.c device.c mempool.c components.c mem.c clock.c thread.c irq.c signal.c idle.c object.c
  group Libraries
    libraries/GD32F30x_Firmware_Library/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
    libraries/GD32F30x_Firmware_Library/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_i2c.c gd32f30x_wwdgt.c gd32f30x_rcu.c gd32f30x_dma.c gd32f30x_usart.c gd32f30x_fwdgt.c gd32f30x_exti.c gd32f30x_gpio.c gd32f30x_misc.c gd32f30x_timer.c
software components: CMSIS:CORE 5.5.0
